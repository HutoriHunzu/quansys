# Ansys Electronics Desktop project, version 2024.2
materials:
  vacuum: permittivity=1
  perfect conductor: conductivity=1e+30
  sapphire: permittivity=10
surface materials:
  Steel-oxidised-surface

design Dualrail_transmon_purcell (HFSS, Eigenmode, model units mm)
variables:
  transmon_coupler_a = 1mm
  transmon_coupler_b = 0.5mm
  transmon_wg_radius = 2mm
  half_cell_Rc = 31mm
  half_cell_Lc = 21mm
  half_cell_fillet_radius = 4mm
  coupler_a = 2mm
  coupler_b = 1mm
  Iris_radius = 14mm
  full_cell_Rc = 30.14mm
  full_cell_Lc = 21mm
  cavity_drive_wg_radius = 8mm
  cavity_drive_wg_length = 18mm
  cavity_z_end = 77.260708mm
  cavity_z_midpoint = 19.252233mm
  cavity_drive_pin_diamter = 1mm
  cavity_drive_pin_length = 3mm
  cavity_drive_pin_encloser_diamter = 2.3mm
  cavity_drive_pin_encloser_length = 4mm
  sapphire_house_length = 22mm
  spacer = 0.001mm
  sapphire_house_pins_diameter = 0.5mm
  sapphire_house_pins_waveguide_diameter = 1.15mm
  sapphire_house_pins_waveguide_length = 6mm
  pin_1_length = 5.6mm
  pin_2_length = 0mm
  pin_3_length = 0mm
  pin_4_length = 7.5mm
  maximum_mesh_size_mm = 2mm
  Chip_thickness = 0.3mm
  Chip_width = 2mm
  Chip_length = 24.7mm
  Antenna_radius = 0.2mm
  Antenna_width = 0.1mm
  Antenna_depth = 0.5mm
  Antenna_transmon_gap = 0mm
  Antenna_rect_width = 1mm
  Antenna_top_x = 0.8mm
  Antenna_top_length = 0.5mm
  Pad_length = 0.4mm
  Pad_width = 1mm
  Lead_width = 0.02mm
  Lead_length = 0.07mm
  Rect_jj_width = 0.004mm
  Rect_jj_length = 0.01mm
  Line_jj_length = 0.01mm
  Transmon_transmon_gap = 0.3mm
  Ro_gap = 0.2mm
  Ro_width = 0.1mm
  Ro_X_length = 1.2mm
  Ro_length = 0.07mm
  Ro_lead_length = 0.6mm
  Ro_reps = 15
  Ro_dualrail_antenna_z = 0.1mm
  Ro_dualrail_antenna_x = 1.5mm
  Purcell_X_length = 1.2mm
  Ro_filter_gap = 4.6mm
  Purcell_lead_length = 0.5mm
  Purcell_reps = 15
  Lj = 13.5nH
geometry:
  cavity [vacuum] = polyline(x=0mm, yz in mm: (0, 77.260708) (0, -0.5) (2, -0.5) (2.0021411, -0.46729844) (2.0085551, -0.4347369) (2.0192147, -0.40245484) (2.0340742, -0.37059048) (2.0530699, -0.33928027) (2.0761205, -0.30865828) (2.1031273, -0.27885565) (2.1339746, -0.25) (2.1685304, -0.22221488) (2.2066467, -0.19561929) (2.2481602, -0.17032709) (2.2928932, -0.14644661) (2.3406542, -0.1240801) (2.3912386, -0.10332333) (2.4444298, -0.084265194) (2.5, -0.066987298) (2.5577113, -0.051563629) (2.6173166, -0.038060234) (2.6785605, -0.026534935) (2.741181, -0.017037087) (2.8049097, -0.0096073598) (2.8694738, -0.0042775693) (2.9345969, -0.0010705384) (3, 0) (5.1099794, 0) (7.2199588, 0) (9.3299383, 0) (11.439918, 0) (13.549897, 0) (15.659877, 0) (17.769856, 0) (19.879835, 0) (21.989815, 0) (24.099794, 0) (26.209774, 0) (26.534532, 0.013205338) (26.857147, 0.05273416) (27.175487, 0.11832547) (27.487451, 0.2095462) (27.790979, 0.32579403) (28.084067, 0.46630143) (28.364779, 0.63014067) (28.631262, 0.81622998) (28.881758, 1.0233407) (29.114611, 1.2501052) (29.328284, 1.4950265) (29.521367, 1.7564872) (29.692584, 2.0327611) (29.840806, 2.3220241) (29.965053, 2.6223661) (30.064505, 2.9318042) (30.138506, 3.2482953) (30.186567, 3.5697496) (30.20837, 3.8940447) (30.203772, 4.2190394) (30.172803, 4.5425879) (30.115667, 4.8625538) (30.032742, 5.1768246) (29.924575, 5.4833252) (29.786964, 5.817008) (29.641246, 6.1491075) (29.48746, 6.4795333) (29.325648, 6.8081954) (29.155854, 7.1350044) (28.978124, 7.4598714) (28.792506, 7.782708) (28.599052, 8.1034261) (28.397813, 8.4219387) (28.188845, 8.7381589) (27.972204, 9.0520007) (27.74795, 9.3633786) (27.516143, 9.672208) (27.276846, 9.9784047) (27.030125, 10.281885) (26.776047, 10.582568) (26.514681, 10.880369) (26.246098, 11.17521) (25.970371, 11.467008) (25.687575, 11.755685) (25.397787, 12.041163) (25.101087, 12.323363) (24.797554, 12.602209) (24.487272, 12.877625) (24.170324, 13.149535) (23.846798, 13.417867) (23.516781, 13.682546) (23.180363, 13.943502) (22.837636, 14.200661) (22.488693, 14.453956) (22.133628, 14.703317) (21.772539, 14.948675) (21.405524, 15.189965) (21.032682, 15.42712) (20.654116, 15.660076) (20.269928, 15.88877) (19.880223, 16.113139) (19.485107, 16.333122) (19.084687, 16.548659) (18.679072, 16.759693) (18.268373, 16.966164) (17.852702, 17.168017) (17.432172, 17.365198) (17.006897, 17.557652) (16.576992, 17.745327) (16.142576, 17.928172) (15.703766, 18.106137) (15.260682, 18.279174) (14.813444, 18.447236) (14.813433, 18.447239) (14.693477, 18.495101) (14.581213, 18.54742) (14.477304, 18.60389) (14.38236, 18.664177) (14.296941, 18.727926) (14.22155, 18.794763) (14.15663, 18.864293) (14.102565, 18.936108) (14.059672, 19.009784) (14.028203, 19.084887) (14.008345, 19.160976) (14.000214, 19.237603) (14.003858, 19.314315) (14.019255, 19.390662) (14.046315, 19.466193) (14.084879, 19.540465) (14.134719, 19.61304) (14.195542, 19.68349) (14.26699, 19.751401) (14.348642, 19.816373) (14.440018, 19.878023) (14.540578, 19.935989) (14.649732, 19.989928) (14.766837, 20.039524) (14.766846, 20.039528) (15.993798, 20.546977) (17.184906, 21.094316) (18.337501, 21.680318) (19.449001, 22.303671) (20.516913, 22.962976) (21.538845, 23.656757) (22.512507, 24.383459) (23.435717, 25.141453) (24.306405, 25.92904) (25.12262, 26.744455) (25.882534, 27.585872) (26.584442, 28.451404) (27.226773, 29.339111) (27.808086, 30.247004) (28.327078, 31.173049) (28.782588, 32.115169) (29.173593, 33.071255) (29.499217, 34.039162) (29.758731, 35.016722) (29.951554, 36.001745) (30.077252, 36.992022) (30.135545, 37.985334) (30.126301, 38.979455) (30.049542, 39.972158) (29.905439, 40.961217) (29.694316, 41.944416) (29.416645, 42.919551) (29.073049, 43.884438) (28.664298, 44.836913) (28.191307, 45.774843) (27.655138, 46.696124) (27.056991, 47.598694) (26.398206, 48.480528) (25.680262, 49.33965) (24.904765, 50.174136) (24.073455, 50.982115) (23.188194, 51.761776) (22.250967, 52.511372) (21.263873, 53.229223) (20.229125, 53.91372) (19.149042, 54.56333) (18.026044, 55.176596) (16.862649, 55.752144) (15.661462, 56.288684) (14.425177, 56.785014) (13.156564, 57.240022) (11.858466, 57.652687) (10.533792, 58.022085) (9.1855114, 58.347389) (9.1855104, 58.347389) (9.0988511, 58.367969) (9.0142653, 58.390604) (8.9319477, 58.41524) (8.8520877, 58.441822) (8.7748691, 58.470288) (8.7004695, 58.500573) (8.6290601, 58.532607) (8.5608052, 58.566316) (8.495862, 58.601624) (8.4343797, 58.638447) (8.3765, 58.676703) (8.3223559, 58.716302) (8.2720721, 58.757154) (8.2257643, 58.799165) (8.183539, 58.842238) (8.1454934, 58.886273) (8.111715, 58.931171) (8.0822815, 58.976826) (8.0572608, 59.023135) (8.0367103, 59.06999) (8.0206773, 59.117284) (8.0091987, 59.164908) (8.002301, 59.212753) (8, 59.260708) (8, 60.010708) (8, 60.760708) (8, 61.510708) (8, 62.260708) (8, 63.010708) (8, 63.760708) (8, 64.510708) (8, 65.260708) (8, 66.010708) (8, 66.760708) (8, 67.510708) (8, 68.260708) (8, 69.010708) (8, 69.760708) (8, 70.510708) (8, 71.260708) (8, 72.010708) (8, 72.760708) (8, 73.510708) (8, 74.260708) (8, 75.010708) (8, 75.760708) (8, 76.510708) (8, 77.260708) (0, 77.260708), covered, Spline from point 2 over 233)
  cavity.sweep_around_axis(axis=Z, angle=360deg)
  saph_house_back_cylin1 = cylinder(axis=Z, base_centre=(0mm, 2.5mm, -sapphire_house_length), radius=3.5mm, height=-spacer)
  saph_house_back_cylin2 = cylinder(axis=Z, base_centre=(0mm, -2.5mm, -sapphire_house_length), radius=3.5mm, height=-spacer)
  sapphire_house_back = box(corner=(-3.5mm, -2.5mm, -sapphire_house_length), size=(7mm, 5mm, -spacer))
  sapphire_house_wg = cylinder(axis=Z, base_centre=(0mm, 0mm, -sapphire_house_length), radius=transmon_wg_radius, height=sapphire_house_length)
  pin_1_wg = cylinder(axis=Y, base_centre=(0mm, 0mm, -8mm), radius=sapphire_house_pins_waveguide_diameter/2, height=transmon_wg_radius + sapphire_house_pins_waveguide_length)
  pin_2_wg = cylinder(axis=Y, base_centre=(0mm, 0mm, -11mm), radius=sapphire_house_pins_waveguide_diameter/2, height=-transmon_wg_radius - sapphire_house_pins_waveguide_length)
  pin_3_wg = cylinder(axis=Y, base_centre=(0mm, 0mm, -15mm), radius=sapphire_house_pins_waveguide_diameter/2, height=transmon_wg_radius + sapphire_house_pins_waveguide_length)
  pin_4_wg = cylinder(axis=Y, base_centre=(0mm, 0mm, -18mm), radius=sapphire_house_pins_waveguide_diameter/2, height=-transmon_wg_radius - sapphire_house_pins_waveguide_length)
  transmon_pin [perfect conductor] = cylinder(axis=Y, base_centre=(0mm, transmon_wg_radius + sapphire_house_pins_waveguide_length, -8mm), radius=sapphire_house_pins_diameter/2, height=-pin_1_length)
  readout_pin [perfect conductor] = cylinder(axis=Y, base_centre=(0mm, -transmon_wg_radius - sapphire_house_pins_waveguide_length, -11mm), radius=sapphire_house_pins_diameter/2, height=pin_2_length)
  pin_3 [perfect conductor] = cylinder(axis=Y, base_centre=(0mm, transmon_wg_radius + sapphire_house_pins_waveguide_length, -15mm), radius=sapphire_house_pins_diameter/2, height=-pin_3_length)
  pin_4 [perfect conductor] = cylinder(axis=Y, base_centre=(0mm, -transmon_wg_radius - sapphire_house_pins_waveguide_length, -18mm), radius=sapphire_house_pins_diameter/2, height=pin_4_length)
  Chip_holder [sapphire] = box(corner=(-Chip_width/2, -Chip_thickness/2, -sapphire_house_length -spacer), size=(Chip_width, Chip_thickness, Chip_length))
  Antenna_top = circle(normal=Y, centre=(0mm, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth), radius=Antenna_radius)
  Antenna_connection = rectangle(corner=(-Antenna_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth), z_size=-Antenna_top_length, x_size=Antenna_width)
  Upper_pad_upper_transmon [perfect conductor] = rectangle(corner=(-Pad_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap), z_size=-Pad_length, x_size=Pad_width)
  Upper_lead_upper_transmon = rectangle(corner=(-Lead_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length), z_size=-Lead_length, x_size=Lead_width)
  Rect_jj_up [perfect conductor] = rectangle(corner=(-Rect_jj_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length), z_size=-Rect_jj_length, x_size=Rect_jj_width)
  Line_jj_up = polyline((0mm, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length) (0mm, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length))
  Lower_lead_upper_Transmon = rectangle(corner=(-Lead_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length), z_size=-Lead_length, x_size=Lead_width)
  Lower_pad_upper_transmon [perfect conductor] = rectangle(corner=(-Pad_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length), z_size=-Pad_length, x_size=Pad_width)
  Upper_pad_lower_transmon [perfect conductor] = rectangle(corner=(-Pad_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap), z_size=-Pad_length, x_size=Pad_width)
  Upper_lead_lower_transmon = rectangle(corner=(-Lead_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length), z_size=-Lead_length, x_size=Lead_width)
  Rect_jj_low [perfect conductor] = rectangle(corner=(-Rect_jj_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length), z_size=-Rect_jj_length, x_size=Rect_jj_width)
  Line_jj_low = polyline((0mm, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length) (0mm, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length))
  Lower_lead_lower_Transmon = rectangle(corner=(-Lead_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length), z_size=-Lead_length, x_size=Lead_width)
  Lower_pad_lower_transmon [perfect conductor] = rectangle(corner=(-Pad_width/2, Chip_thickness/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length), z_size=-Pad_length, x_size=Pad_width)
  RORes = polyline(y=Chip_thickness/2, xz: (0+Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z) (0+Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2) (0+Ro_width/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2) (0+Ro_width/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_lead_length-Ro_width/2) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_lead_length+Ro_width/2) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Ro_X_length/2-Ro_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length) (0-Ro_width/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2-Ro_length) (0-Ro_width/2+Ro_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2) (0-Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_width/2) (0-Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z) (0-Ro_dualrail_antenna_x/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z) (0-Ro_dualrail_antenna_x/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z+Ro_dualrail_antenna_z) (0+Ro_dualrail_antenna_x/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z+Ro_dualrail_antenna_z) (0+Ro_dualrail_antenna_x/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z) (0+Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z))
  RORes.fillet(Vertices=RORes.vertex(at (0.05, 0.15, -0.801)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.05, 0.15, -1.351)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -1.351)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -1.621)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -1.621)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -1.691)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -1.691)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -1.961)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -1.961)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.031)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.031)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.301)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.301)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.371)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.371)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.641)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.641)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.711)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.711)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -2.981)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -2.981)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -3.051)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -3.051)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -3.321)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -3.321)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -3.391)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -3.391)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -3.661)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -3.661)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -3.731)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -3.731)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.001)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.001)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.071)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.071)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.341)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.341)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.411)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.411)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.681)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.681)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -4.751)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -4.751)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.021)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.021)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.091)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.091)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.361)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.361)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.431)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.431)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.701)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.701)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -5.771)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -5.771)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -6.041)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -6.041)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -6.111)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -6.111)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.65, 0.15, -6.381)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -6.381)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.55, 0.15, -6.451)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.05, 0.15, -6.451)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.05, 0.15, -7.101)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.05, 0.15, -7.101)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.05, 0.15, -6.551)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -6.551)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -6.281)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -6.281)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -6.211)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -6.211)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.941)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.941)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.871)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.871)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.601)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.601)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.531)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.531)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.261)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.261)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -5.191)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -5.191)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.921)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.921)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.851)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.851)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.581)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.581)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.511)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.511)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.241)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.241)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -4.171)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -4.171)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.901)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.901)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.831)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.831)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.561)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.561)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.491)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.491)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.221)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.221)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -3.151)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -3.151)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.881)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.881)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.811)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.811)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.541)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.541)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.471)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.471)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.201)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.201)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -2.131)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -2.131)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -1.861)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -1.861)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -1.791)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -1.791)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.65, 0.15, -1.521)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -1.521)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.55, 0.15, -1.451)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.05, 0.15, -1.451)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.05, 0.15, -0.801)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.75, 0.15, -0.801)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (-0.75, 0.15, -0.701)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.75, 0.15, -0.701)) Radius=0.01mm Setback=0mm)
  RORes.fillet(Vertices=RORes.vertex(at (0.75, 0.15, -0.801)) Radius=0.01mm Setback=0mm)
  RORes.cover_lines()
  PurcellFilter = polyline(y=Chip_thickness/2, xz: (0+Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap) (0+Ro_width/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2) (0+Ro_width/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2) (0+Ro_width/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0+Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length+Ro_width/2-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Purcell_lead_length-Ro_width/2) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Purcell_lead_length+Ro_width/2) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_filter_gap-Purcell_lead_length-Ro_width/2-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length-Ro_length-Ro_width-Ro_width-Ro_length) (0-Ro_width/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length+Purcell_X_length/2+Purcell_X_length/2-Purcell_X_length, Chip_length - sapphire_house_length - spacer-antenna_depth-Antenna_top_length-Antenna_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length-Pad_length-Transmon_transmon_gap-Pad_length-Lead_length-Line_jj_length-Lead_length - Pad_length-Ro_gap-Ro_dualrail_antenna_z-Ro_lead_length-Ro_lead_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_length-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_width-Ro_wi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